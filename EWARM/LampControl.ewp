# IAR project LampControl.ewp, settings and files
configuration LampControl (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431CB ST STM32G431CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G431xx; __IASMARM__; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc; ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32G4xx/Include; ../Drivers/CMSIS/Include; ..\stm32lib; ..\Core\Src\GUI; ..\stm32lib\crypto; D:\GOOD\StroboScope\LampControl2.0\cm_backtrace
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  AARM.ADefines: __IASMARM__; ARM_MATH_CM4
  OBJCOPY.OOCOutputFile: LampControl.hex
  ILINK.IlinkOutputFile: LampControl.out
  ILINK.IlinkIcfFile: stm32g431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g431xx.s
  group Application/stm32lib
    ../stm32lib/: AppParaCommon.c flash.c Reset.c SysParaCommon.c utility.c
  group Application/stm32lib/crypto
    ../stm32lib/crypto/: aes.c aes_test .c des.c des_test.c tea.c tea_test.c
  group Application/User/Core
    ../Core/Src/: adc.c AppInterface.cpp AppPara.c ctrl.c ctrl_common.c encoder.c HardFault_Handler.c KeyAndKnob_lamp2.c Lcd.c lcd_stmf4.c main.cpp rtc_int.c share.c stm32g4xx_hal_msp.c stm32g4xx_it.c SysPara.c timer.c
  group Application/User/Core/GUI
    ../Core/Src/GUI/: AboutPage.cpp EngineeringSetupPage.cpp font_ascii.c font_ascii_Song16_10p.c font_ascii_Song16_11p.c font_ascii_Song_w10_h16.c font_hz_song12.c fonts.c GUI_Display.cpp GUI_ListPage.cpp GUI_NumPage.cpp GUI_Object.cpp GUI_Page.cpp GUI_Speed.cpp Icons.cpp Logo.cpp MainPage.cpp MenuPage.cpp MenuPage_Battery.cpp MenuPage_Layser.cpp MenuPage_Option.cpp MenuPage_PulseWidth.cpp MenuPage_SpeedUnit.cpp MenuTitlePage.cpp PowerSetupPage.cpp ScanAdcPage.cpp ScanSpeedPage.cpp SubPage.cpp SystemSetupPage.cpp
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/CMSIS/DSP_Lib/Source/CommonTables
    ../Drivers/CMSIS/DSP_Lib/Source/CommonTables/: arm_common_tables.c
  group Drivers/CMSIS/DSP_Lib/Source/Transformfunctions
    ../Drivers/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_bitreversal.c arm_bitreversal2.s arm_cfft_f32.c arm_cfft_radix8_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_exti.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_wwdg.c stm32g4xx_ll_adc.c
